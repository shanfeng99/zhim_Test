# Keil uVision project STC15F2KXX.uvproj, settings and files
target STC15F2KXX (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15F2K60S2 +hex
  c flags: Optimize=9 SizeSpeed=1
  group C FILES
    ../USER/: io.c led.c main.c system.c expand.c
  group H FILES
    ../USER/: STC15F2KXX.h io.h led.h system.h TP.h expand.h
